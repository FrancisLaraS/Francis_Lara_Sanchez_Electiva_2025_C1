# Repository FrancisLaraS/Francis_Lara_Sanchez_Electiva_2025_C1

File README.md:

# Francis_Lara_Sanchez_Electiva_2025_C1
Espacio para trabajos y tareas.

## KiCad design ProtectoUSB/Proyecto USB.kicad_pcb

Board: 2 copper layers, 55.9 x 22.2 mm, 27 parts (2 on the bottom side), 21 nets.

Parts:
C1, C2, C3, C4: 0.1uF; C0603
C5, C8: 47uF 16v; CAP-SMD_BD5.0-L5.3-W5.3-LS6.3-FD
C6, C7: 10uF 16v; C0805
D1, D2: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
L1, L2: WE-CNSW_1206; WE-CNSW_1206_WE-CNSW_1206
LED1: XL-1608SURC-06; LED0603-RD_RED
R1, R2, R3, R4, R5, R6: 0R; R0603
R7, R8, R9, R10: 1K; R0603
U1: ADUM3160BRWZ; WSOIC-16_L10.3-W7.5-P1.27-LS10.3-BL
U2: B0505S-1W_C7465127; PWRM-TH_B0505S-1W
USB1: USB-B01; USB-B-TH_USB-B01
USB2: U-USBAR04P-F001; USB-A-TH_USB-302-T

Connections:
+5V: C1.1, C2.1, C5.1, C6.2, D1.5, R3.2, R9.1, U1.1 (VBUS1), U1.3 (VDD1), U1.4 (PDEN), U2.2 (+VIN), USB1.1 (VBUS)
/D0+: D1.3, USB1.3 (D+)
/D0-: D1.1, USB1.2 (D-)
/D1+: D1.4, L1.2, R2.1
/D1-: D1.6, L1.3, R1.1
/D2+: L1.1, R2.2, U1.7 (UD+)
/D2-: L1.4, R1.2, U1.6 (UD-)
/D3+: L2.2, R8.1, U1.10 (DD+)
/D3-: L2.3, R7.1, U1.11 (DD-)
/D4+: D2.3, L2.1, R8.2
/D4-: D2.1, L2.4, R7.2
/D5+: D2.4, USB2.3 (D+)
/D5-: D2.6, USB2.2 (D-)
Earth: C3.2, C4.2, C7.2, C8.2, D2.2, R6.1, U1.9 (GND2), U1.15 (GND2), U2.3 (-VOUT), USB2.4 (GND), USB2.5 (SH1), USB2.6 (SH2)
GND: C1.2, C2.2, C5.2, C6.1, D1.2, LED1.1 (K), R4.1, U1.2 (GND1), U1.8 (GND1), U2.1 (-VIN), USB1.4 (GND), USB1.5 (GND), USB1.6 (GND)
unnamed: LED1.2 (A), R9.2
unnamed: R10.1, U1.12 (PIN)
unnamed: R5.1, R6.2, U1.13 (SPD)
unnamed: R3.1, R4.2, U1.5 (SPU)
unnamed: R10.2, U1.14 (VDD2)
VCC: C3.1, C4.1, C7.1, C8.1, D2.5, R5.2, U1.16 (VBUS2), U2.4 (+VOUT), USB2.1 (VCC)

## KiCad design Proyecto 1 Kicad/Proyecto 1 Kicad/Proyecto 1 Kicad.kicad_pcb

Parts:
AE1: Antenna; Texas_SWRA117D_2.4GHz_Right
C1: 1n; C_01005_0402Metric
C2: 33n; C_01005_0402Metric
C3: 10n; C_01005_0402Metric
C6, C9: C_Small; C_01005_0402Metric
C7: 1p5; C_01005_0402Metric
C8: 1p; C_01005_0402Metric
C10, C11: cx; C_01005_0402Metric
J1: Conn_01x08_Pin; Hirose_DF13-08P-1.25DSA_1x08_P1.25mm_Vertical
L1: 8n2; L_0402_1005Metric
L2, L4: 3n9; L_0402_1005Metric
L3: 2n7; L_0402_1005Metric
R1: 22k; R_01005_0402Metric
R2: 10M; R_01005_0402Metric
U1: NRF24L01; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
c4, c5: 22p; C_01005_0402Metric
y1: 16MHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
GND: C1.2, C2.2, C3.2, C6.2, C8.2, C9.2, C10.2, C11.2, J1.8, R1.2, U1.8 (VSS), U1.14 (VSS), U1.17 (VSS), U1.20 (VSS), c4.2, c5.2
unnamed: AE1.1 (A), C11.1, L4.2
unnamed: C7.1, L2.2
unnamed: C7.2, C8.1, C10.1, L4.1
unnamed: J1.2, U1.4 (MOSI)
unnamed: J1.3, U1.5 (MISO)
unnamed: J1.4, U1.3 (SCK)
unnamed: J1.5, U1.2 (CSN)
unnamed: J1.6, U1.1 (CE)
unnamed: J1.7, U1.6 (IRQ)
unnamed: L1.1, L2.1, U1.12 (ANT1)
unnamed: L1.2, L3.1, U1.13 (ANT2)
unnamed: C2.1, U1.19 (DVDD)
unnamed: R1.1, U1.16 (IREF)
unnamed: C6.1, C9.1, L3.2, U1.11 (VDD_PA)
unnamed: R2.2, U1.10 (XC1), c5.1, y1.2
unnamed: R2.1, U1.9 (XC2), c4.1, y1.1
VDD: C1.1, C3.1, J1.1, U1.7 (VDD), U1.15 (VDD), U1.18 (VDD)

Board: 2 copper layers, 19.3 x 24.1 mm, 21 parts (0 on the bottom side), 18 nets.

## Commit log

2025-02-05 Create README.md
    Espacio para trabajos y tareas
